options:
  parameters:
    author: mathe
    generate_options: qt_gui
    id: Decode_Simulation
    output_language: python
    title: Decode Simulation
  states: {}

blocks:
- name: Tag_Frequency
  id: variable_qtgui_chooser
  parameters:
    label0: 10k
    label1: 15k
    label2: 20k
    label3: 25k
    label4: '0'
    num_opts: '5'
    option0: '10000'
    option1: '15000'
    option2: '20000'
    option3: '25000'
    option4: '0'
    type: int
    value: '10000'
  states: {}
- name: amplitude
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '.00001'
    stop: '1'
    value: '0'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: moving_avg
  id: variable
  parameters:
    value: '10'
  states: {}
- name: off_gain
  id: variable_qtgui_range
  parameters:
    start: '-2'
    step: '.1'
    stop: '0'
    value: '-0.69'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '.000075'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '.000075'
    freq: '300000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: amplitude*2
    freq: Tag_Frequency
    offset: '-amplitude'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_0_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_0_0_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_1
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_add_xx_0_1_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_add_xx_0_1_1
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_1_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_2
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_3
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_1_0_1
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_len
  states: {}
- name: blocks_complex_to_mag_squared_1_0_1_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_len
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '4000'
    scale: 1/1000
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '10000'
    max_iter: '4000'
    scale: 1/10000
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: moving_avg
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_0_1
  id: blocks_moving_average_xx
  parameters:
    length: '10000'
    max_iter: '4000'
    scale: 1/10000
    type: float
  states: {}
- name: blocks_moving_average_xx_0_1_0
  id: blocks_moving_average_xx
  parameters:
    length: moving_avg
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_0_1_0_0
  id: blocks_moving_average_xx
  parameters:
    length: moving_avg
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_0_2
  id: blocks_moving_average_xx
  parameters:
    length: moving_avg
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_0_2_0
  id: blocks_moving_average_xx
  parameters:
    length: '10000'
    max_iter: '4000'
    scale: 1/10000
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10000/moving_avg
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10000/moving_avg
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10000/moving_avg
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: 10000/moving_avg
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: off_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: off_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_1
  id: blocks_multiply_const_vxx
  parameters:
    const: off_gain
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_nlog10_ff_0_0_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: fft_len
  states: {}
- name: blocks_nlog10_ff_0_0_1_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_0_0_1_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_0_0_1_0_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_0_0_1_0_2
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_len
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_len
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_1
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0'
    init: '0'
    low: '0'
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: '0'
    init: '0'
    low: '0'
  states: {}
- name: blocks_threshold_ff_0_1
  id: blocks_threshold_ff
  parameters:
    high: '0'
    init: '0'
    low: '0'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class vector_average(gr.sync_block):
          """
          Vector Average Block
          Inputs: Vector of samples
          Outputs: Single float representing the average
          """
          def __init__(self, vector_len=1):
              self.vector_len = vector_len
              gr.sync_block.__init__(
                  self,
                  name='Vector Average',
                  in_sig=[(np.float32, 8192)],
                  out_sig=[np.float32]
              )

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              
              # Calculate average for each input vector
              for i in range(len(out)):
                  out[i] = np.mean(in0[i])
              
              return len(output_items[0])
    vector_len: fft_len
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self, scale = 1.0):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='FFT Selector',
                  in_sig=[(np.complex64, 8192)],
                  out_sig=[np.complex64, np.complex64, np.complex64, np.complex64]
              )
              self.scale = scale

          def work(self, input_items, output_items):
              output_items[0][0] = input_items[0][0][6676]*self.scale
              output_items[1][0] = input_items[0][0][6717]*self.scale
              output_items[2][0] = input_items[0][0][6758]*self.scale
              output_items[3][0] = input_items[0][0][6635]*self.scale
              # output_items[0][0] = input_items[0][0][835]*self.scale
              # output_items[1][0] = input_items[0][0][840]*self.scale
              # output_items[2][0] = input_items[0][0][845]*self.scale
              # output_items[3][0] = input_items[0][0][830]*self.scale        
              return 1
    scale: '1'
  states: {}
- name: epy_block_1_0_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self, true_frequency=1):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='Error Rate Output',
                  in_sig=[np.float32, np.float32, np.float32],
                  out_sig=[]
              )
              # Initialize class variables
              self.true_frequency = true_frequency
              self.index = 0
              self.falseNeg = 0
              self.falsePos = 0

          # This is the method GRC will call to update the variable
          def set_true_frequency(self, frequency):
              self.true_frequency = frequency

          def work(self, input_items, output_items):
              # Access instance variables instead of globals
              for i in range(len(input_items[0])):
                  self.index += 1
                  if self.true_frequency == 15000:
                      if not input_items[0][i]:
                          self.falseNeg = self.falseNeg + 1
                      if input_items[1][i] or input_items[2][i]:
                          self.falsePos = self.falsePos + 1

                  if self.true_frequency == 20000:
                      if not input_items[1][i]:
                          self.falseNeg = self.falseNeg + 1
                      if input_items[0][i] or input_items[2][i]:
                          self.falsePos = self.falsePos + 1

                  if self.true_frequency == 25000:
                      if not input_items[2][i]:
                          self.falseNeg = self.falseNeg + 1
                      if input_items[1][i] or input_items[0][i]:
                          self.falsePos = self.falsePos + 1

                  if self.true_frequency == 10000:
                      if input_items[1][i] or input_items[0][i] or input_items[2][i]:
                          self.falsePos = self.falsePos + 1
                  
                  if self.index == 100000:
                      # print("\033[2F\033[0J", end = "")
                      print("Decode Sample: ", input_items[0][i], " || Test Sample: ", self.true_frequency)
                      print("index: ", self.index, " || False Negatives: ", self.falseNeg, " || False Positives: ", self.falsePos, " || False Negative rate: ", self.falseNeg/self.index, " || False Positive rate: ", self.falsePos/self.index)
                      self.index = 0
                      self.falseNeg = 0
                      self.falsePos = 0
              
              return len(input_items[0])
    true_frequency: Tag_Frequency
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: float
    window: window.blackmanharris(fft_len)
  states: {}
- name: fft_vxx_0_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: float
    window: window.blackmanharris(fft_len)
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '20'
    min: '0'
    nconnections: '3'
    type: float
  states: {}
- name: qtgui_number_sink_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '0'
    min: '-150'
    name: '"Average Power"'
    type: float
  states: {}
- name: qtgui_vector_sink_f_0_0_1
  id: qtgui_vector_sink_f
  parameters:
    name: '"Manual"'
    vlen: fft_len
    x_start: '0'
    x_step: '1.0'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_0, '0', blocks_stream_to_vector_0_0_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_add_xx_0_0_0, '0', blocks_threshold_ff_0_0, '0']
- [blocks_add_xx_0_0_0_0, '0', blocks_threshold_ff_0_1, '0']
- [blocks_add_xx_0_0_0_1, '0', blocks_threshold_ff_0, '0']
- [blocks_add_xx_0_1, '0', blocks_multiply_const_vxx_1_1, '0']
- [blocks_add_xx_0_1_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_add_xx_0_1_1, '0', blocks_multiply_const_vxx_1_0, '0']
- [blocks_complex_to_mag_squared_0_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_complex_to_mag_squared_0_0_0, '0', blocks_nlog10_ff_0_0_1_0_2, '0']
- [blocks_complex_to_mag_squared_0_1_0, '0', blocks_multiply_const_vxx_0_2, '0']
- [blocks_complex_to_mag_squared_0_1_0, '0', blocks_nlog10_ff_0_0_1_0_0, '0']
- [blocks_complex_to_mag_squared_0_2, '0', blocks_multiply_const_vxx_0_1_0_0, '0']
- [blocks_complex_to_mag_squared_0_3, '0', blocks_multiply_const_vxx_0_1_0, '0']
- [blocks_complex_to_mag_squared_0_3, '0', blocks_nlog10_ff_0_0_1_0_1, '0']
- [blocks_complex_to_mag_squared_1_0_1, '0', blocks_nlog10_ff_0_0_1, '0']
- [blocks_complex_to_mag_squared_1_0_1_0, '0', epy_block_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_number_sink_0_0_0, '0']
- [blocks_moving_average_xx_0_0, '0', qtgui_number_sink_0, '0']
- [blocks_moving_average_xx_0_0_0, '0', blocks_add_xx_0_0_0, '0']
- [blocks_moving_average_xx_0_0_0, '0', blocks_add_xx_0_1_0, '1']
- [blocks_moving_average_xx_0_0_0, '0', blocks_add_xx_0_1_1, '1']
- [blocks_moving_average_xx_0_1, '0', qtgui_number_sink_0, '2']
- [blocks_moving_average_xx_0_1_0, '0', blocks_add_xx_0_0_0_0, '0']
- [blocks_moving_average_xx_0_1_0, '0', blocks_add_xx_0_1, '1']
- [blocks_moving_average_xx_0_1_0, '0', blocks_add_xx_0_1_1, '0']
- [blocks_moving_average_xx_0_1_0_0, '0', blocks_add_xx_0_1, '2']
- [blocks_moving_average_xx_0_1_0_0, '0', blocks_add_xx_0_1_0, '2']
- [blocks_moving_average_xx_0_1_0_0, '0', blocks_add_xx_0_1_1, '2']
- [blocks_moving_average_xx_0_2, '0', blocks_add_xx_0_0_0_1, '0']
- [blocks_moving_average_xx_0_2, '0', blocks_add_xx_0_1, '0']
- [blocks_moving_average_xx_0_2, '0', blocks_add_xx_0_1_0, '0']
- [blocks_moving_average_xx_0_2_0, '0', qtgui_number_sink_0, '1']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_moving_average_xx_0_0_0, '0']
- [blocks_multiply_const_vxx_0_1_0, '0', blocks_moving_average_xx_0_1_0, '0']
- [blocks_multiply_const_vxx_0_1_0_0, '0', blocks_moving_average_xx_0_1_0_0, '0']
- [blocks_multiply_const_vxx_0_2, '0', blocks_moving_average_xx_0_2, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_0_0_0_0, '1']
- [blocks_multiply_const_vxx_1_0, '0', blocks_add_xx_0_0_0_1, '1']
- [blocks_multiply_const_vxx_1_1, '0', blocks_add_xx_0_0_0, '1']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_nlog10_ff_0_0_1, '0', qtgui_vector_sink_f_0_0_1, '0']
- [blocks_nlog10_ff_0_0_1_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_nlog10_ff_0_0_1_0, '0', blocks_sub_xx_0, '1']
- [blocks_nlog10_ff_0_0_1_0, '0', blocks_sub_xx_0_0, '1']
- [blocks_nlog10_ff_0_0_1_0, '0', blocks_sub_xx_0_1, '1']
- [blocks_nlog10_ff_0_0_1_0_0, '0', blocks_sub_xx_0, '0']
- [blocks_nlog10_ff_0_0_1_0_1, '0', blocks_sub_xx_0_0, '0']
- [blocks_nlog10_ff_0_0_1_0_2, '0', blocks_sub_xx_0_1, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_stream_to_vector_0_0_0, '0', fft_vxx_0_0_0, '0']
- [blocks_sub_xx_0, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_sub_xx_0_0, '0', blocks_moving_average_xx_0_1, '0']
- [blocks_sub_xx_0_1, '0', blocks_moving_average_xx_0_2_0, '0']
- [blocks_threshold_ff_0, '0', epy_block_1_0_0, '0']
- [blocks_threshold_ff_0_0, '0', epy_block_1_0_0, '1']
- [blocks_threshold_ff_0_1, '0', epy_block_1_0_0, '2']
- [epy_block_0, '0', blocks_nlog10_ff_0_0_1_0, '0']
- [epy_block_0_0, '0', blocks_complex_to_mag_squared_0_1_0, '0']
- [epy_block_0_0, '1', blocks_complex_to_mag_squared_0_0_0, '0']
- [epy_block_0_0, '2', blocks_complex_to_mag_squared_0_3, '0']
- [epy_block_0_0, '3', blocks_complex_to_mag_squared_0_2, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_mag_squared_1_0_1, '0']
- [fft_vxx_0_0, '0', epy_block_0_0, '0']
- [fft_vxx_0_0_0, '0', blocks_complex_to_mag_squared_1_0_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
