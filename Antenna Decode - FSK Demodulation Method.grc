options:
  parameters:
    author: mathe
    generate_options: qt_gui
    id: Antenna_Test
    output_language: python
    title: Antenna Test
  states: {}

blocks:
- name: Period_Length
  id: variable
  parameters:
    value: '150'
  states: {}
- name: cent_freq
  id: variable
  parameters:
    value: '916000000'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: moving_avg
  id: variable
  parameters:
    value: '10'
  states: {}
- name: off_gain
  id: variable
  parameters:
    value: '-0.9'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '.01'
    stop: '1'
    value: '1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: blocks_add_xx_0_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_0_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_0_0_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_1
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_add_xx_0_1_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_add_xx_0_1_1
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_2
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_len
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: Test
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_1
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: moving_avg
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: moving_avg
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_0_1
  id: blocks_moving_average_xx
  parameters:
    length: moving_avg
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_0_1_0
  id: blocks_moving_average_xx
  parameters:
    length: moving_avg
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10000/moving_avg
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10000/moving_avg
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 10000/moving_avg
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10000/moving_avg
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: off_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: off_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_1
  id: blocks_multiply_const_vxx
  parameters:
    const: off_gain
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: fft_len
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_len
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: Period_Length
    type: byte
  states: {}
- name: blocks_stream_to_vector_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: Period_Length
    type: byte
  states: {}
- name: blocks_stream_to_vector_1_1
  id: blocks_stream_to_vector
  parameters:
    num_items: Period_Length
    type: byte
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0'
    init: '0'
    low: '0'
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: '0'
    init: '0'
    low: '0'
  states: {}
- name: blocks_threshold_ff_0_1
  id: blocks_threshold_ff
  parameters:
    high: '0'
    init: '0'
    low: '0'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self, scale = 1.0):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='FFT Selector',
                  in_sig=[(np.complex64, 8192)],
                  out_sig=[np.complex64, np.complex64, np.complex64, np.complex64]
              )
              self.scale = scale

          def work(self, input_items, output_items):
              output_items[0][0] = input_items[0][0][6681]*self.scale
              output_items[1][0] = input_items[0][0][6720]*self.scale
              output_items[2][0] = input_items[0][0][6761]*self.scale
              output_items[3][0] = input_items[0][0][6641]*self.scale
              return 1
    scale: '1'
  states: {}
- name: epy_block_1_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      # Global counter — shared across all instances
      counter = 0

      class blk(gr.sync_block):
          def __init__(self, threshold=15):
              gr.sync_block.__init__(
                  self,
                  name='Combined Vector Check and Compare',
                  in_sig=[(np.uint8, 150), (np.uint8, 150), (np.uint8, 150)],
                  out_sig=[np.uint8]
              )
              self.threshold = threshold

          def work(self, input_items, output_items):
              global counter

              in0 = input_items[0]
              in1 = input_items[1]
              in2 = input_items[2]
              out = output_items[0]

              num_vectors = len(in0)
              print(f"[DEBUG] Global pass {counter}: {num_vectors} vector sets processed\n")

              for i in range(num_vectors):
                  count0 = np.count_nonzero(in0[i] == 1)
                  count1 = np.count_nonzero(in1[i] == 1)
                  count2 = np.count_nonzero(in2[i] == 1)

                  result0 = 1 if count0 > self.threshold else 0
                  result1 = 1 if count1 > self.threshold else 0
                  result2 = 1 if count2 > self.threshold else 0

                  if result0 == 1:
                      out[i] = 1
                  elif result1 == 1:
                      out[i] = 2
                  elif result2 == 1:
                      out[i] = 3
                  else:
                      out[i] = 0

                  print(f"[DEBUG] Vec {i}: counts=({count0}, {count1}, {count2}), "
                        f"results=({result0}, {result1}, {result2}), output={out[i]}\n")

              counter += 1
              return num_vectors
    threshold: '9'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_len)
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: 15k
    label2: 20k
    label3: 25k
    min: '0'
    name: '"Tone Binary"'
    nconnections: '3'
    type: float
  states: {}
- name: qtgui_number_sink_0_0_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: 15k
    min: '0'
    name: '"Tone Binary Long"'
    type: byte
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    rate: '100'
    type: complex
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: fft_len
    x_start: '0'
    x_step: '1.0'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: cent_freq + 300000
    dev_addr: '"addr=192.168.10.2"'
    gain0: tx_gain
    gain_type0: normalized
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: cent_freq
    dev_addr: '"addr=192.168.10.3"'
    gain0: '0'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']
- [blocks_add_xx_0_0_0, '0', blocks_threshold_ff_0_0, '0']
- [blocks_add_xx_0_0_0_0, '0', blocks_threshold_ff_0_1, '0']
- [blocks_add_xx_0_0_0_1, '0', blocks_threshold_ff_0, '0']
- [blocks_add_xx_0_1, '0', blocks_multiply_const_vxx_1_1, '0']
- [blocks_add_xx_0_1_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_add_xx_0_1_1, '0', blocks_multiply_const_vxx_1_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_complex_to_mag_squared_0_1, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_mag_squared_0_2, '0', blocks_multiply_const_vxx_0_1_0, '0']
- [blocks_complex_to_mag_squared_1, '0', blocks_nlog10_ff_0, '0']
- [blocks_float_to_char_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_float_to_char_0_0, '0', blocks_stream_to_vector_1_0, '0']
- [blocks_float_to_char_0_1, '0', blocks_stream_to_vector_1_1, '0']
- [blocks_moving_average_xx_0, '0', blocks_add_xx_0_0_0_1, '0']
- [blocks_moving_average_xx_0, '0', blocks_add_xx_0_1, '0']
- [blocks_moving_average_xx_0, '0', blocks_add_xx_0_1_0, '0']
- [blocks_moving_average_xx_0_0, '0', blocks_add_xx_0_0_0, '0']
- [blocks_moving_average_xx_0_0, '0', blocks_add_xx_0_1_0, '1']
- [blocks_moving_average_xx_0_0, '0', blocks_add_xx_0_1_1, '1']
- [blocks_moving_average_xx_0_1, '0', blocks_add_xx_0_0_0_0, '0']
- [blocks_moving_average_xx_0_1, '0', blocks_add_xx_0_1, '1']
- [blocks_moving_average_xx_0_1, '0', blocks_add_xx_0_1_1, '0']
- [blocks_moving_average_xx_0_1_0, '0', blocks_add_xx_0_1, '2']
- [blocks_moving_average_xx_0_1_0, '0', blocks_add_xx_0_1_0, '2']
- [blocks_moving_average_xx_0_1_0, '0', blocks_add_xx_0_1_1, '2']
- [blocks_multiply_const_vxx_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_moving_average_xx_0_1, '0']
- [blocks_multiply_const_vxx_0_1_0, '0', blocks_moving_average_xx_0_1_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_0_0_0_0, '1']
- [blocks_multiply_const_vxx_1_0, '0', blocks_add_xx_0_0_0_1, '1']
- [blocks_multiply_const_vxx_1_1, '0', blocks_add_xx_0_0_0, '1']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_1, '0', epy_block_1_0_0_0, '0']
- [blocks_stream_to_vector_1_0, '0', epy_block_1_0_0_0, '1']
- [blocks_stream_to_vector_1_1, '0', epy_block_1_0_0_0, '2']
- [blocks_threshold_ff_0, '0', blocks_float_to_char_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_number_sink_0_0, '0']
- [blocks_threshold_ff_0_0, '0', blocks_float_to_char_0_0, '0']
- [blocks_threshold_ff_0_0, '0', qtgui_number_sink_0_0, '1']
- [blocks_threshold_ff_0_1, '0', blocks_float_to_char_0_1, '0']
- [blocks_threshold_ff_0_1, '0', qtgui_number_sink_0_0, '2']
- [epy_block_0, '0', blocks_complex_to_mag_squared_0_1, '0']
- [epy_block_0, '1', blocks_complex_to_mag_squared_0_0, '0']
- [epy_block_0, '2', blocks_complex_to_mag_squared_0, '0']
- [epy_block_0, '3', blocks_complex_to_mag_squared_0_2, '0']
- [epy_block_1_0_0_0, '0', blocks_file_sink_0, '0']
- [epy_block_1_0_0_0, '0', qtgui_number_sink_0_0_1, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_1, '0']
- [fft_vxx_0, '0', epy_block_0, '0']
- [uhd_usrp_source_0, '0', blocks_stream_to_vector_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
